# Keil uVision project GPIO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: GD32F303VE GigaDevice
  cpu: IRAM(0x20000000-0x2000FFFF)IROM(0x08000000-0x0807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
  output: GPIO +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: GD32F30X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SystemRegister;..\GD32F30x_standard_peripheral\Include;..\SystemClock;..\bsp\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Starup
    ../Starup/: startup_gd32f30x_hd.s
  group Perpheral
    ../GD32F30x_standard_peripheral/Source/: gd32f30x_rcu.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_spi.c
  group SystemClock
    ../SystemClock/: system_gd32f30x.c
  group User
    ./: main.c
  group SystemRegister
    ../SystemRegister/: gd32f30x_it.c
  group bsp
    ../bsp/src/: bsp_gpio.c bsp_lcd.c bsp_delay.c
